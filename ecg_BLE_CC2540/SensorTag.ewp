# IAR project SensorTag.ewp, settings and files
configuration CC2541DK-Sensor (8051)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_I2C=FALSE; HAL_ADC=TRUE; HAL_KEY=TRUE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: SensorProfile; Source; CC2540ST; lib; tools; 
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: tools\ti_51ew_cc2540b.xcl
configuration CC2541DK-Sensor-OAD-ImgA (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_A; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_I2C=TRUE; HAL_ADC=FALSE
  ICC8051.CCIncludePath2: ..\..\common; ..\..\include; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2541ST; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Profiles\Roles; ..\..\Profiles\SensorProfile; ..\..\Profiles\Keys; ..\..\Profiles\DevInfo; ..\..\Profiles\Oad
  ICC8051.CCOptLevel: 3
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541DK-Sensor-OAD-ImgA\Exe\SensorTag"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgA.xcl
configuration CC2541DK-Sensor-OAD-ImgB (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: as above
  ICC8051.CCDefines: FEATURE_OAD_BIM; HAL_IMAGE_B; FEATURE_OAD; OAD_KEEP_NV_PAGES; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; POWER_SAVING; HAL_LCD=FALSE; HAL_LED=TRUE; HAL_I2C=TRUE; HAL_ADC=FALSE
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptLevel: 3
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "CC2541DK-Sensor-OAD-ImgB\Exe\SensorTag"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgB.xcl
  group (top)
    ./: att.h bcomdef.h comdef.h gap.c gap.h gapbondmgr.c gapbondmgr.h gapgattserver.h gatt.h gatt_uuid.c gatt_uuid.h gattservapp.h hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.c hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h hci.h hci_data.h hci_event.h hci_tl.h l2cap.h linkdb.h ll.h ll_math.h ll_sleep.h ll_timer2.h npi.c npi.h OSAL.c OSAL.h osal_bufmgr.c osal_bufmgr.h osal_cbtimer.c osal_cbtimer.h OSAL_Clock.h OSAL_ClockBLE.c OSAL_Memory.c OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.c OSAL_PwrMgr.h osal_snv.c osal_snv.h OSAL_Tasks.h OSAL_Timers.c OSAL_Timers.h phy.h phy_image.h saddr.h sm.h ZComDef.h
  group CC2540ST
    CC2540ST/: hal_acc.c hal_acc.h hal_adc.c hal_aes.c hal_aes.h hal_assert.c hal_bar.c hal_bar.h hal_board_cfg.h hal_crc.c hal_crc.h hal_dma.c hal_dma.h hal_flash.c hal_gyro.c hal_gyro.h hal_humi.c hal_humi.h hal_i2c.c hal_i2c.h hal_interrupt.c hal_irtemp.c hal_irtemp.h hal_keys.c hal_keys.h hal_led.c hal_mag.c hal_mag.h hal_mcu.h hal_sensor.c hal_sensor.h hal_sleep.c hal_startup.c hal_timer.c hal_types.h hal_uart.c
  group lib
    lib/: CC2540_BLE_peri.lib CC254x_BLE_HCI_TL_None.lib
  group SensorProfile
    SensorProfile/: accelerometerservice.c accelerometerservice.h irtempservice.c irtempservice.h peripheral.c peripheral.h simplekeys.c simplekeys.h st_util.c st_util.h testservice.c testservice.h
  group Source
    Source/: devinfoservice-st.c devinfoservice-st.h OSAL_SensorTag.c SensorTag.c SensorTag.h SensorTag_Main.c
  group tools
    tools/: buildComponents.cfg buildConfig.cfg OnBoard.c OnBoard.h
